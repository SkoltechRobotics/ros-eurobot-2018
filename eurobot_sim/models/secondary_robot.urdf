Commit message: model of secondary robot improved

File: eurobot_sim/models/secondary_robot.urdf (robot description, URDF)
Before this commit: robot secondary_robot, 1 links, 0 joints
Links:
- link secondary_robot: geometry visual box size=0.241 0.060 0.25; visual box size=0.241 0.166 0.35
