Commit message: much better organized simulation

File: eurobot_sim/models/main_robot.urdf (robot description, URDF)
Before this commit: robot main_robot, 1 links, 0 joints
Links:
- link main_robot: geometry collision box size=0.1 0.19 0.34; collision box size=0.11 0.19 0.34
